# Keil uVision project Develop.uvprojx, settings and files
target Develop (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Develop +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\CORE;..\HALLIB\Inc;..\HALLIB\Src;..\HARDWARE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\OLED;..\HARDWARE\RGB;..\HARDWARE\SMG;..\HARDWARE\BEE;..\HARDWARE\BH1750;..\HARDWARE\DS18B20;..\HARDWARE\ULT;..\HARDWARE\TIME;..\HARDWARE\KEY;..\HARDWARE\EC11;..\HARDWARE\UART;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\ADC;..\EXTEND\INIT;..\EXTEND\DHT11;..\EXTEND\WS2812;..\EXTEND\GP2Y0A21;..\EXTEND\HX711;..\EXTEND\MPU6050;..\EXTEND\MPU6050\eMPL;..\EXTEND\IIC;..\EXTEND\SK6812;..\EXTEND\MLX90614;..\EXTEND\RC522;..\EXTEND\HMC5883L;..\SYSTEM\usart;..\EXTEND\ADXL345;..\HARDWARE\GUI;..\EXTEND\PAJ7620U2;..\APP;..\HARDWARE\RNG;..\HARDWARE\RTC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
    ../HARDWARE/GUI/: MYGUI.c MYGUI_FUNC.c
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h startup_stm32f407xx.s
  group HALLIB
    ../HALLIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/RGB/: rgb.c
    ../HARDWARE/SMG/: smg.c
    ../HARDWARE/BEE/: bee.c
    ../HARDWARE/BH1750/: BH1750.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/ULT/: ultrasonic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EC11/: ec11.c
    ../HARDWARE/UART/: uart.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/ADC/: adc.c
  group SYSTEM
    ../HARDWARE/TIME/: time.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../HARDWARE/RNG/: RNG.c
    ../HARDWARE/RTC/: RTC.c
  group TXT
    ../TXT/: Update_Record .TXT
  group EXTEND
    ../EXTEND/INIT/: init.c
    ../EXTEND/DHT11/: dht11.c
    ../EXTEND/GP2Y0A21/: GP2Y0A21.C
    ../EXTEND/HX711/: HX711.C
    ../EXTEND/MPU6050/: mpu6050.c
    ../EXTEND/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../EXTEND/SK6812/: SK6812.c
    ../EXTEND/MLX90614/: MLX90614.c
    ../EXTEND/IIC/: MY_iic.c MRIIC.c
    ../EXTEND/RC522/: rc522.c
    ../EXTEND/HMC5883L/: HMC5883L.c
    ../EXTEND/ADXL345/: ADXL345.c
    ../EXTEND/PAJ7620U2/: paj7620u2.c
  group APP
    ../APP/: Voltage.C
